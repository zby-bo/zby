# Keil uVision project STM32F042_Demo.uvprojx, settings and files
target Target 1 ()
  group Source
    ./:  
  group Startup
    ./: 
